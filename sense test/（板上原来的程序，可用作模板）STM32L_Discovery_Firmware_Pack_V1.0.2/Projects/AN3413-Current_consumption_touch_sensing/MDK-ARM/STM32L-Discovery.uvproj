# Keil uVision project STM32L-Discovery.uvproj, settings and files
target STM32L-Discovery (ARM-ADS)
  device: STM32L152RB STMicroelectronics
  cpu: IRAM(0x20000000-0x20003FFF) IROM(0x8000000-0x801FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: STM32L-Discovery
  c flags: Optim=4
  c define: STM32L15XXB_128K USE_STDPERIPH_DRIVER
  c include: ..\inc;..\..\..\libraries\CMSIS\CM3\DeviceSupport\ST\STM32L1xx;..\..\..\libraries\STM32L1xx_StdPeriph_Driver\inc;..\..\..\libraries\STM32_TouchSensing_Driver\inc;..\..\..\Utilities\STM32L-DISCOVERY
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x3c00
  memory RVCT10: RAM 0x20003c00 size 0x400
  group CMSIS
    ../../../Libraries/CMSIS/CM3/CoreSupport/: core_cm3.c
  group STM32L1xx_StdPeriph_Driver
    ../../../Libraries/STM32L1xx_StdPeriph_Driver/src/: stm32l1xx_syscfg.c misc.c stm32l1xx_adc.c stm32l1xx_exti.c stm32l1xx_flash.c stm32l1xx_gpio.c stm32l1xx_lcd.c stm32l1xx_pwr.c stm32l1xx_rcc.c stm32l1xx_rtc.c
  group TouchSensing Driver
    ../../../Libraries/STM32_TouchSensing_Driver/src/: stm32_tsl_api.c stm32_tsl_multichannelkey.c stm32_tsl_services.c stm32_tsl_singlechannelkey.c stm32_tsl_timebase.c stm32l15x_tsl_ct_acquisition.c
  group STM32L-Discovery
    ../../../Utilities/STM32L-DISCOVERY/: stm32l_discovery_lcd.c
  group User
    ../src/: stm32l1xx_it.c main.c icc_measure_Ram.c icc_measure.c discover_functions.c system_stm32l1xx.c
  group DOC
    ../: Readme.txt
  group MDK-ARM
    ../../../Libraries/CMSIS/CM3/DeviceSupport/ST/STM32L1xx/startup/arm/: startup_stm32l1xx_md.s
